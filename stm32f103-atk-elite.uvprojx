# Keil uVision project stm32f103-atk-elite.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCompiler5)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_LIBC, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __RTTHREAD__, STM32F103xE, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;board;..\..\..\components\libc\posix\ipc;..\libraries\HAL_Drivers\drivers;.;..\..\..\components\libc\posix\io\poll;..\..\..\include;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;applications;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\cortex-m3;..\..\..\components\libc\compilers\common\extension;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\..\..\components\libc\compilers\common\include;..\libraries\HAL_Drivers\CMSIS\Include;..\libraries\HAL_Drivers;board\CubeMX_Config\Inc;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: msh_parse.c cmd.c shell.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pwr.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_rcc_ex.c
